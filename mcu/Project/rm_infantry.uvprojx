# Keil uVision project rm_infantry.uvprojx, settings and files
target rm_infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rm_infantry +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ..\Inc;..\Inc\hal_inc;..\Inc\m3_inc;..\Inc\os_inc;..\Inc\hal_inc\Legacy;..\User;..\User\algorithm;..\User\app;..\User\driver;..\User\BSP;..\User\driver
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group user_driver
    ../User/: rm_hal_lib.h
    ../User/driver/: rm_can.c rm_uart.c rm_gpio.c
  group user_algorithm
    ../User/algorithm/: pid.c utility.c
  group user_app
    ../User/: startup.c
    ../User/app/: study_task.c motor_task.c communication_task.c communication_task.h
  group user_custom
    ../User/: sys.h
  group lib_rm
    ../Inc/: stm32f4xx_it.c rm_infantry1_3.lib
